CVE_STATUS[CVE-2014-8171] = "not-applicable-config"
CVE_STATUS[CVE-2016-0774] = "not-applicable-config"

